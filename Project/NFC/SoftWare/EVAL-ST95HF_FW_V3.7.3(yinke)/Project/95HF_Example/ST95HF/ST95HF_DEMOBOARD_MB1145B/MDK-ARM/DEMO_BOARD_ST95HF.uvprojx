# Keil uVision project DEMO_BOARD_ST95HF.uvprojx, settings and files
target DEMO_BOARD_ST95HF (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103RG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO_BOARD_ST95HF +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_XL, ST95HF, USE_MB1145_BOARD
  c include: ..\inc;..\..\..\..\..\libraries\95HF\inc;..\..\..\..\..\libraries\USB-FS-Device_Driver\inc;..\..\..\..\..\libraries\USB_Composite\inc;..\..\..\..\..\libraries\USB_MSD\inc;..\..\..\..\..\libraries\CMSIS\CM3\CoreSupport;..\..\..\..\..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\..\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\..\Utilities\ST95HF_DEMOBOARD_MB1145B\LCD\inc;..\..\..\..\..\Utilities\ST95HF_DEMOBOARD_MB1145B\LCD\pictures;..\..\..\..\..\Utilities\ST95HF_DEMOBOARD_MB1145B\LED\inc;..\..\..\..\..\libraries\NDEF\inc;..\sys;..\usart;..\..\..\..\..\libraries\M1_Mcc\inc;..\M1emulation
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User_Appli
    ../src/: main.c menu_auto.c PongExample.c proprietary_p2p.c hw_config.c stm32f10x_it.c common.c Firmware_Saving.c menu.c menu_cardemul.c menu_reader.c menu_Tagemul.c menu_writer.c miscellaneous.c
  group 95HF_Driver
    ../../../../../libraries/95HF/src/: drv_95HF.c drv_spi.c drv_interrupt.c drv_uart.c
  group 95HF_PCD_Libraries
    ../../../../../libraries/95HF/src/: lib_nfctype1pcd.c lib_nfctype2pcd.c lib_nfctype3pcd.c lib_nfctype4pcd.c lib_nfctype5pcd.c lib_iso7816pcd.c lib_iso14443Apcd.c lib_iso14443Bpcd.c lib_iso15693pcd.c lib_iso18092pcd.c lib_PCD.c
  group 95HF_PICC_Libraries
    ../../../../../libraries/95HF/src/: lib_PICCemulator.c lib_nfctype2picc.c lib_nfctype4picc.c lib_cardemul.c lib_iso7816picc.c lib_iso14443Apicc.c lib_PICC.c
  group 95HF_P2P_Libraries
    ../../../../../libraries/95HF/lib/: DEMO_BOARD_ST95HF.lib
    ../../../../../libraries/95HF/src/: lib_proprietaryP2P.c
  group 95HF_Manager_Libraries
    ../../../../../libraries/95HF/src/: lib_ConfigManager.c
  group NDEF
    ../../../../../libraries/NDEF/src/: lib_flash_ndef.c lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_SMS.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Text.c lib_95HF_wrapper.c
  group StdPeriph_Driver
    ../../../../../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User_Drivers
    ../../../../../Utilities/ST95HF_DEMOBOARD_MB1145B/LCD/src/: drv_lcdspi_ili9341.c
    ../../../../../Utilities/ST95HF_DEMOBOARD_MB1145B/LED/src/: drv_LED.c
  group USB_FS_Driver
    ../../../../../libraries/USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_Composite
    ../../../../../libraries/USB_Composite/src/: usb_desc.c usb_endp.c usb_hid.c usb_istr.c usb_prop.c usb_pwr.c
  group USB_MSD
    ../../../../../libraries/USB_MSD/src/: mass_mal.c memory.c msd_rw.c nand_if.c scsi_data.c usb_bot.c usb_scsi.c
  group MDK-ARM
    ./: startup_stm32f10x_xl.s
  group CMSIS
    ../../../../../libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Drivers/M1_mcc
    ../../../../../libraries/M1_Mcc/src/: mcc.c mcc_crypto.c mcc_crypto_card.c mcc_crypto_reader.c mcc_macros.c mcc_raw_request.c rfal_crc.c
  group Yinke/Log
    ../usart/: usart.c
    ../sys/: sys.c
  group Yinke/M1Emulation
    ../M1emulation/: lib_nfcm1picc.c
