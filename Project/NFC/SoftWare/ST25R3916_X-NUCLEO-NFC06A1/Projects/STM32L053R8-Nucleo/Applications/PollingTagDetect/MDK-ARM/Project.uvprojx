# Keil uVision project Project.uvprojx, settings and files
target STM32L053R8-Nucleo_PollingTagDetect (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IROM(0x08000000-0x800FFFF) IRAM(0x20000000-0x20001FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L476RG_NUCLEO_PollingTagDetect +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER,USE_LOGGER,USE_FULL_ASSERT,USE_HAL_SPI_REGISTER_CALLBACKS
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/BSP/Components/ST25R3916;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../Drivers/BSP/NFC06A1;../../../../../Middlewares/ST/rfal/Inc;../../../../../Middlewares/ST/rfal/Src;../../../../../Middlewares/ST/rfal/Src/st25r3916
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Applications/MDK-ARM
    ./: startup_stm32l053xx.s
  group Applications/User
    ../Src/: analogConfigTbl_NFC06A1.c demo_polling.c demo_ce.c logger.c main.c nucleo_l053r8_bus.c stm32l0xx_hal_exti.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/ST25R3916
    ../../../../../Drivers/BSP/Components/ST25R3916/: st25r3916.c st25r3916_com.c st25r3916_irq.c st25r3916_led.c timer.c
  group Drivers/BSP/NFC06A1
    ../../../../../Drivers/BSP/NFC06A1/: nfc06a1.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
  group Middlewares/ST/RFAL
    ../../../../../Middlewares/ST/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
    ../../../../../Middlewares/ST/rfal/Src/st25r3916/: rfal_rfst25r3916.c
software components: CMSIS:CORE 5.1.2
