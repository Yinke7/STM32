# IAR project Project.ewp, settings and files
configuration STM32L476RG-Nucleo_PollingTagDetect (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; USE_LOGGER; USE_HAL_SPI_REGISTER_CALLBACKS
  ICCARM.CCDiagSuppress: Pa182
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\Drivers\BSP\Components\ST25R3916; ..\..\..\..\..\Drivers\BSP\NFC06A1; ..\..\..\..\..\Middlewares\ST\rfal\Inc; ..\..\..\..\..\Middlewares\ST\rfal\Src\st25r3916; ..\..\..\..\..\Middlewares\ST\rfal\Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L476RG_NUCLEO_PollingTagDetect.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L476RG_NUCLEO_PollingTagDetectNdef (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; USE_LOGGER; USE_HAL_SPI_REGISTER_CALLBACKS; NDEF_FEATURE_FULL_API
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\Drivers\BSP\Components\ST25R3916; ..\..\..\..\..\Drivers\BSP\NFC06A1; ..\..\..\..\..\Middlewares\ST\rfal\Inc; ..\..\..\..\..\Middlewares\ST\ndef\Inc\message; ..\..\..\..\..\Middlewares\ST\ndef\Inc\poller; ..\..\..\..\..\Middlewares\ST\rfal\Src\st25r3916; ..\..\..\..\..\Middlewares\ST\rfal\Src
  OBJCOPY.OOCOutputFile: STM32L476RG_NUCLEO_PollingTagDetectNdef.bin
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ST25R3916/: st25r3916.c st25r3916_com.c st25r3916_irq.c st25r3916_led.c timer.c
  group Drivers/BSP/NFC06A1
    ../../../../../Drivers/BSP/NFC06A1/: nfc06a1.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Example/EWARM
    ./: startup_stm32l476xx.s
  group Example/User
    ../Src/: analogConfigTbl_NFC06A1.c demo_ce.c demo_polling.c logger.c main.c ndef_demo.c ndef_dump.c nucleo_l476rg_bus.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Middlewares/NDEF
    ../../../../../Middlewares/ST/ndef/Src/message/: ndef_message.c ndef_record.c ndef_type_wifi.c ndef_types.c ndef_types_mime.c ndef_types_rtd.c
    ../../../../../Middlewares/ST/ndef/Src/poller/: ndef_poller.c ndef_t2t.c ndef_t3t.c ndef_t4t.c ndef_t5t.c
  group Middlewares/RFAL
    ../../../../../Middlewares/ST/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
    ../../../../../Middlewares/ST/rfal/Src/st25r3916/: rfal_rfst25r3916.c
