# Keil uVision project Project.uvprojx, settings and files
target STM32L476RG-Nucleo_PollingTagDetect (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476RG_NUCLEO_PollingTagDetect +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,USE_LOGGER,USE_HAL_SPI_REGISTER_CALLBACKS
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Middlewares\ST\rfal\Inc;..\..\..\..\..\Middlewares\ST\rfal\Src\st25r3916;..\..\..\..\..\Drivers\BSP\Components\ST25R3916;..\..\..\..\..\Middlewares\ST\rfal\Src;..\..\..\..\..\Drivers\BSP\NFC06A1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: stm32l4xx_it.c main.c demo_polling.c demo_ce.c logger.c stm32l4xx_hal_msp.c analogConfigTbl_NFC06A1.c nucleo_l476rg_bus.c ndef_demo.c ndef_dump.c
  group Example/MDK-ARM
    ./: startup_stm32l476xx.s
  group Middlewares/ST/RFAL
    ../../../../../Middlewares/ST/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
    ../../../../../Middlewares/ST/rfal/Src/st25r3916/: rfal_rfst25r3916.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ST25R3916/: st25r3916.c st25r3916_com.c st25r3916_irq.c st25r3916_led.c timer.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_flash_ex.c
  group Drivers/BSP/NFC06A1
    ../../../../../Drivers/BSP/NFC06A1/: nfc06a1.c
  group Drivers/BSP/STM32L476RG_NUCLEO
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Middlewares/ST/NDEF
    ../../../../../Middlewares/ST/ndef/Src/message/: ndef_message.c ndef_record.c ndef_types.c ndef_types_mime.c ndef_types_rtd.c ndef_type_wifi.c
    ../../../../../Middlewares/ST/ndef/Src/poller/: ndef_poller.c ndef_t2t.c ndef_t3t.c ndef_t4t.c ndef_t5t.c
target STM32L476RG-Nucleo_PollingTagDetectNdef (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: as above
  output: STM32L476RG_NUCLEO_PollingTagDetectNdef +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,USE_LOGGER, USE_HAL_SPI_REGISTER_CALLBACKS,NDEF_FEATURE_FULL_API
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Middlewares\ST\rfal\Inc;..\..\..\..\..\Middlewares\ST\rfal\Src\st25r3916;..\..\..\..\..\Drivers\BSP\Components\ST25R3916;..\..\..\..\..\Middlewares\ST\rfal\Src;..\..\..\..\..\Drivers\BSP\NFC06A1;..\..\..\..\..\Middlewares\ST\ndef\Inc\message;..\..\..\..\..\Middlewares\ST\ndef\Inc\poller
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
